# Repository Elecrow-RD/CrowPanel-3.5-HMI-ESP32-Display-480x320

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | old |
| 1    | V1.1     | V1.0     | old |
| 1    | V2.0     | V1.0     | old |
| 1    | V2.2     | V2.2     | latest |

**Version 2.0** upgrades the automatic download feature from Version 1.0.

**Version 2.2** modifies two pins based on Version 2.0. The following modifications are required:
#define TFT_MISO 33
#define TOUCH_CS 12

### 3, product informatio

- Model: 3.5 inches module-CrowPanel ESP32 display
- Main Processor: ESP32-WROVER-B
- Resolution: 480*320
- Touch Type: Resistive Touch Screen
- Display Type: TN Panel
- Screen: TFT-LCD Screen
- Display driver: ILI9488
- External power supply: DC5V-2A
- Interface: 1\*TF Card Slot, 1\* I2C, 1* GPIO, 1\*Speak, 1* UART1, 1*UART0
- Button: BOOT Button and Reset Button
- Active Area: 48.96\*73.44mm(W*H)
- Working Temperature: -20℃～70℃
- Storage Temperature: -30℃～80℃

### 4, Use the driver module

| Name | dependency library |
| ---- | ------------------ |
| LVGL | lvgl/lvgl@8.3.3    |

### 5,Quick Start

##### Arduino IDE starts

1.Download the library files used by this product to the 'libraries' folder.

C:\Users\Documents\Arduino\libraries\

2.Open the Arduino IDE

3.Open the code configuration environment and burn it

##### ESP-IDF starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the IDF plug-in, select the port, then compile and flash

##### PlatformIO starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the PlatformIO plug-in, select the port, then compile and flash

##### Micropython starts

1,Right-click on an empty space in the project folder and select "Thonny" to open the project.

2,In thonny software, select the master and port, then run the program

### 6,Folder structure.

|--3D file： Contains 3D model files (.stp) for the hardware. These files can be used for visualization, enclosure design, or integration into CAD software.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

|--factory_sourcecode: Contains the source code for the factory firmware, allowing users to modify and rebuild the firmware as needed.

### 7,Pin definition

\#define TFT_MISO 12 

#define TFT_MOSI 13 // In some display driver board, it might be written as "SDA" and so on. 

#define TFT_SCLK 14 

#define TFT_CS   15  // Chip select control pin 

#define TFT_DC   2  // Data Command control pin 

#define TFT_RST  -1  // Reset pin (could connect to Arduino RESET pin) 

#define TFT_BL   27  // LED back-light 

#define TOUCH_CS 33     // Chip select pin (T_CS) of touch screen

For the latest v2.2 board, the following modifications need to be made:

#define TFT_MISO 33

#define TOUCH_CS 12`

## EAGLE design Eagle_SCH&PCB/V2.1/CrowPanel ESP32 Display-3.5-V2.1-20240312.brd

Parts:
C1: 10uF; DISCRETE_C0603
C2, C3, C4, C5, C9, C10, C12, C13, C15, C16, C17, C26: 100nF; 0603
C6, C8: 1uF; 0603
C7, C42: 22uF; 0805
C11: 4.7uF; 0603
C14, C22, C53, C55: 1uF; DISCRETE_C0603
C18, C19, C20, C21: 100pF/NC; 0603
C23: 4.7uF/NC; 0603
C46: 1nF; DISCRETE_C0603
C47, C48, C49: 10uF; 0805_S
C50: 100nF; C0603
C51: 100pF; DISCRETE_C0603
C54: 4.7uF; DISCRETE_C0603
D3: S2M/SMB; 214AB
D5: IN5817; DO-214AC
J1: QD351801; QD351801-0.8MM*48
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J5, J8: PH2.0WT-2PIN
J6, J7, J10: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
K1, K4: BUTTON; 157SW
L4: L-0530; CD54_CD54
LED1: RED; DISCRETE_LED-0603
P1, P2: PADPAD-1.0MM; PAD-1.0MM
Q3: PMOS-3401-4A; SOT-23
Q6: 2N7002; SOT23
Q9, Q10: S9013; SOT23@1
R1, R10, R16, R17, R21, R23, R24, R38, R67: 10K; DISCRETE_R0603
R2: 47R/NC; DISCRETE_R0603
R3, R18, R25, R26, R27, R35, R36, R45, R50, R74, R75: 1K; DISCRETE_R0603
R4: 10K; R0603
R5: 2K; DISCRETE_R0603
R7, R11, R28, R29, R32, R33: 3.9R; DISCRETE_R0603
R8, R9, R71, R72: 22R; DISCRETE_R0603
R12: 4.7K; DISCRETE_R0603
R13, R14: 5.1K; DISCRETE_R0603
R19, R30, R31, R46: 0R; DISCRETE_R0603
R20: 45.3K; DISCRETE_R0603
R22: 22K; DISCRETE_R0603
R34, R39: 1K/NC; DISCRETE_R0603
R37: 68K; DISCRETE_R0603
R40, R41: 10K/NC; DISCRETE_R0603
R44: 0R/NC; DISCRETE_R0603
R47: NC/1K; DISCRETE_R0603
SD1: HOLDER-MICROSD-9P; 9P-SMD-W/-RING
TFT-18PIN1: QD281801; QD241801-18PIN*0.8
U1: RY3420; A_XBJ_SOT23-5
U2: SC8002B; AT24C02_SOP8
U3: XP2046; XP2046-SSOP16
U6: CH340C; SOP-16
U24: ESP32-WROVER-B; ESP32-WROOM-32-N4
U26: 4054A; SOP23-5

Connections:
3.3V: C12.2, C55.2, R31.1, U2.6 (VDD)
3V3: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C13.2, C15.2, C16.2, C17.2, C22.2, C26.1, C54.2, J1.P$5 (VDD), J1.P$6 (IOVCC), J1.P$42 (LEDA), J6.3, J7.3, J10.3, L4.2, R3.2, R4.1, R10.2, R16.1, R17.1, R18.2, R20.1, R23.1, R24.1, R25.2, R26.2, R27.2, R31.2, R34.2, R35.2, R36.2, R39.2, R41.1, R47.2, R50.2, R67.1, SD1.4 (VDD), TFT-18PIN1.P$9 (VCC), TFT-18PIN1.P$10 (LED-A), U3.1 (VCC), U3.9 (VREF), U3.10 (IOVDD), U6.4 (V3), U6.16 (VCC), U24.2 (VDD33)
AGND: C12.1, C46.1, C51.1, C53.2, C55.1, J8.P$3, J8.P$4, R30.1, U2.1 (SHUTDOWN), U2.7 (GND)
BAT+: C47.2, C48.2, D5.A, J5.P$1, Q3.3 (D), U26.3 (BAT)
BYPASS_IN+: C53.1, U2.2 (BYPASS), U2.3 (+IN)
D+: J3.A6 (DP1), J3.B6 (DP2), R9.1
D-: J3.A7 (DN1), J3.B7 (DN2), R8.1
DTR: Q10.2 (E), R75.2, U6.13 (DTR#)
EN_RESET: C11.1, K4.2, Q9.3 (C), R4.2, R46.2, U24.3 (EN)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C13.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.2, C26.2, C42.1, C47.1, C48.1, C49.1, C50.2, C54.1, J1.P$14 (GND), J1.P$33 (GND2), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$6, J3.P$7, J3.P$8, J3.P$9, J5.P$2, J5.P$3, J5.P$4, J6.4, J6.SS1, J6.SS2, J7.4, J7.SS1, J7.SS2, J10.4, J10.SS1, J10.SS2, K1.1, K4.1, LED1.-, Q6.2 (S), R1.1, R5.2, R13.1, R14.2, R21.2, R30.2, R38.2, R40.2, R44.1, SD1.6 (VSS), SD1.G1, SD1.G2, SD1.G3, SD1.G4, TFT-18PIN1.P$1 (GND), TFT-18PIN1.P$8 (GND2), U1.2 (GND), U3.6 (GND), U6.1 (GND), U24.1 (GND), U24.15 (GND), U24.15@1 (GND), U24.38 (GND), U24.41 (GND), U24.42 (GND), U24.43 (GND)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
IN-: R22.2, R37.1, U2.4 (-IN)
IO0_BOOT: K1.2, Q10.3 (C), U24.25 (GPIO0,ADC2_CH1,TOUCH1,RTC_GPIO11,CLK_OU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)
IO2_TFT_RS: J1.P$9 (DCX), TFT-18PIN1.P$4 (D/C), U24.24 (GPIO2,ADC2_CH2,TOUCH2,RTC_GPIO12,HSPIWP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), U24.24@1 (GPIO2,ADC2_CH2,TOUCH2,RTC_GPIO12,HSPIWP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)
IO4_PROT_A/D: U24.26 (GPIO4,ADC2_CH0,TOUCH0,RTC_GPIO10,HSPIHD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)
IO5_TF_CS: R67.2, SD1.2 (CD/DATA3), U24.29 (GPIO5,VSPICS0,HS1_DATA6,EMAC_RX_CLK)
IO12_TFT_SDO/TP_OUT: R40.1, U3.12 (DOUT), U24.14 (GPIO12,ADC2_CH5,TOUCH5,RTC_GPIO15,MTDI,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)
IO13_TFT_SDI/TP_DIN: J1.P$12 (SDA), R39.1, TFT-18PIN1.P$6 (SDA), U3.14 (DIN), U24.16 (GPIO13,ADC2_CH4,TOUCH4,RTC_GPIO14,MTCK,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), U24.16@1 (GPIO13,ADC2_CH4,TOUCH4,RTC_GPIO14,MTCK,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)
IO14_TFT_CLK/TP_CLK: J1.P$10 (WRX/SCL), R34.1, TFT-18PIN1.P$3 (SCL), U3.16 (DCLK), U24.13 (GPIO14,ADC2_CH6,TOUCH6,RTC_GPIO16,MTMS,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)
IO15_TFT_CS: J1.P$8 (CSX), TFT-18PIN1.P$5 (CS), U24.23 (GPIO15,ADC2_CH3,TOUCH3,MTDO,HSPICS0,RTC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), U24.23@1 (GPIO15,ADC2_CH3,TOUCH3,MTDO,HSPICS0,RTC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)
IO18_TF_SPI_CLK: SD1.5 (SCLK), U24.30 (GPIO18,VSPICLK,HS1_DATA7)
IO19_TF_SPI_MISO: R24.2, SD1.7 (DATA0), U24.31 (GPIO19,VSPIQ,U0CTS,EMAC_TXD0)
IO21_SCL: J6.1, R26.1, U24.33 (GPIO21,VSPIHD,EMAC_TX_EN)
IO22_SDA: J6.2, R27.1, U24.36 (GPIO22,VSPIWP,U0RTS,EMAC_TXD1)
IO23_TF_SPI_MOSI: R23.2, SD1.3 (CMD), U24.37 (GPIO23,VSPID,HS1_STROBE)
IO25_PROT_A/D: J7.1, R18.1, U24.10 (GPIO25,DAC_1,ADC2_CH8,RTC_GPIO6,EMAC_RX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)
IO26_SPEAK: R12.1, U24.11 (GPIO26,DAC_2,ADC2_CH9,RTC_GPIO7,EMAC_RX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)
IO27_LCD_BLK_CTR: Q6.1 (G), R38.1, U24.12 (GPIO27,ADC2_CH7,TOUCH7,RTC_GPIO17,EMAC_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)
IO32_PROT_A/D: J7.2, R25.1, U24.8 (GPIO32,XTAL_32K_P,ADC1_CH4,TOUCH9,RTC_G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)
IO33_TP_CS: U3.15 (CS), U24.9 (GPIO33,XTAL_32K_N,ADC1_CH5,TOUCH8,RTC_G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)
IO34_PROT_A/D: U24.6 (GPIO34,ADC1_CH6,RTC_GPIO4)
IO35_PROT_A/D: U24.7 (GPIO35,ADC1_CH7,RTC_GPIO5)
IO36_TP_IRQ: R10.1, U3.11 (PENIRQ), U24.4 (SENSOR_VP,GPIO36,ADC1_CH0,RTC_GPIO0)
IO39_PROT_A: U24.5 (SENSOR_VN,GPIO39,ADC1_CH3,RTC_GPIO3)
LEDK: Q6.3 (D), R2.2, R7.2, R11.1, R28.1, R29.1, R32.1, R33.1
LEDK1: R2.1, TFT-18PIN1.P$11 (LED-K), TFT-18PIN1.P$12 (LED-K2), TFT-18PIN1.P$13 (LED-K3), TFT-18PIN1.P$14 (LED-K4)
unnamed: LED1.+, R3.1
unnamed: Q9.1 (B), R75.1
unnamed: C46.2, R12.2, R19.1
unnamed: R41.2, U3.7 (VBAT)
unnamed: J1.P$15 (DB0), J1.P$16 (DB1), J1.P$17 (DB2), J1.P$18 (DB3), J1.P$19 (DB4), J1.P$20 (DB5), J1.P$21 (DB6), J1.P$22 (DB7), J1.P$23 (DB8), J1.P$24 (DB9), J1.P$25 (DB10), J1.P$26 (DB11), J1.P$27 (DB12), J1.P$28 (DB13), J1.P$29 (DB14), J1.P$30 (DB15), J1.P$31 (DB16), J1.P$32 (DB17), R44.2
unnamed: J3.B5 (CC2), R14.1
unnamed: J3.A5 (CC1), R13.2
unnamed: J1.P$44 (LEDK2), R11.2
unnamed: J1.P$11 (RD), P2.P$1
unnamed: U24.17 (*GPIO9,SD_DATA2,SPIHD,HS1_DATA2,U1RXD), U24.17@1 (*GPIO9,SD_DATA2,SPIHD,HS1_DATA2,U1RXD)
unnamed: U24.18 (*GPIO10,SD_DATA3,SPIWP,HS1_DATA3,U1TXD), U24.18@1 (*GPIO10,SD_DATA3,SPIWP,HS1_DATA3,U1TXD)
unnamed: J1.P$43 (LEDK), R7.1
unnamed: L4.1, U1.3 (SW)
unnamed: J1.P$39 (IM2), R35.1
unnamed: U24.19 (*GPIO11,SD_CMD,SPICS0,HS1_CMD,U1RTS), U24.19@1 (*GPIO11,SD_CMD,SPICS0,HS1_CMD,U1RTS)
unnamed: J1.P$40 (IM1), R36.1
unnamed: J1.P$41 (IM0), R50.1
unnamed: J1.P$7 (TE), P1.P$1
unnamed: U24.20 (*GPIO6,SD_CLK,SPICLK,HS1_CLK,U1CTS), U24.20@1 (*GPIO6,SD_CLK,SPICLK,HS1_CLK,U1CTS)
unnamed: R20.2, R21.1, U1.5 (FB)
unnamed: Q3.1 (G), R1.2, R45.1
unnamed: R5.1, U26.5 (PROG)
unnamed: U24.21 (*GPIO7,SD_DATA0,SPIQ,HS1_DATA0,U2RTS), U24.21@1 (*GPIO7,SD_DATA0,SPIQ,HS1_DATA0,U2RTS)
unnamed: U24.22 (*GPIO8,SD_DATA1,SPID,HS1_DATA1,U2CTS), U24.22@1 (*GPIO8,SD_DATA1,SPID,HS1_DATA1,U2CTS)
unnamed: C14.1, C51.2, R19.2
unnamed: C14.2, R22.1
unnamed: J1.P$45 (LEDK3), R28.2
unnamed: J1.P$46 (LEDK4), R29.2
unnamed: J1.P$47 (LEDK5), R32.2
unnamed: J1.P$48 (LEDK6), R33.2
unnamed: Q10.1 (B), R74.1
unnamed: R72.2, U6.2 (TXD)
unnamed: R71.2, U6.3 (RXD)
unnamed: R16.2, SD1.1 (DATA2)
unnamed: R17.2, SD1.8 (DATA1)
RTS: Q9.2 (E), R74.2, U6.14 (RTS#)
TFT_RESET: C23.1, J1.P$38 (RESET), R46.1, R47.1, TFT-18PIN1.P$2 (RESET)
TP_X+: C21.2, J1.P$4 (XR), TFT-18PIN1.P$15 (XL), U3.2 (XP)
TP_X-: C19.2, J1.P$2 (XL), TFT-18PIN1.P$17 (XR), U3.4 (XN)
TP_Y+: C20.2, J1.P$1 (YU), TFT-18PIN1.P$18 (YD), U3.3 (YP)
TP_Y-: C18.2, J1.P$3 (YD), TFT-18PIN1.P$16 (YU), U3.5 (YN)
UART0_RXD0: J10.1, R72.1, U24.34 (RXD0,GPIO3,CLK_OUT2)
UART0_TXD0: J10.2, R71.1, U24.35 (TXD0,GPIO1,CLK_OUT3,EMAC_RXD2)
USB_D+: R9.2, U6.5 (UD+)
USB_D-: R8.2, U6.6 (UD-)
VBUS: C49.2, C50.1, D3.1 (+), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R45.2, U26.4 (VCC)
VIN: C6.2, C42.2, D3.2 (-), D5.C, Q3.2 (S), U1.1 (EN), U1.4 (VIN)
VO1: J8.P$1, R37.2, U2.5 (VO1)
VO2: J8.P$2, U2.8 (VO2)

Notes on the sheet:
Vout=0.6*(R20/R21 +1)=3.3V
系统3.3V电源
UART1接口
主控 ESP32-WROOM-32-N4
USB type-c座子
电池及控制电路
IO0: 低电平：下载启动 高电平：SPI启动
EN: 高电平：芯片使能； 低电平：芯片关闭。
USB转串口
SPEAK 功放
TF Card
BOOT
RESET
POWER LED
LCD+TP 接口
TP驱动:XPT2046
3.5寸屏兼容，其他型号不需要
HM3416H更换为RY3420
500mA
BAT

Board: 2 copper layers, 101.5 x 59.5 mm, 114 parts (2 on the bottom side), 80 nets.

Other parts of the board:
U$2: 3.5底板框
U$3, U$28: LOGE-2.0
U$30: ELECROW-NEW

## Commit log (part)

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2026-04-19 Update readme by removing an image and fixing layout
    Removed an image and adjusted formatting in the readme.
2026-04-19 Fix formatting of interface and active area descriptions
2026-06-15 V2.2
2026-06-22 Micropython
2026-06-22 ESP_IDF
2026-06-23 PlatformIO
2026-06-25 .gitignore
2026-06-25 .pio
